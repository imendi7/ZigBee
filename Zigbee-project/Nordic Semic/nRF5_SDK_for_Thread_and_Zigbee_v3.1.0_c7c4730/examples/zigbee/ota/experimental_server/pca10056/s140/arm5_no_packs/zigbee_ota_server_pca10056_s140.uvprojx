# Keil uVision project zigbee_ota_server_pca10056_s140.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 BOOTLOADER_START_ADDR=BOOTLOADER_ADDRESS CONFIG_GPIO_AS_PINRESET DEBUG DEBUG_NRF ENABLE_FEM FLOAT_ABI_HARD KEIL MULTIPROTOCOL_802154_CONFIG_PRESENT NRF52840_XXAA NRF_BL_SETTINGS_PAGE_PROTECT=0 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 ZB_TRACE_LEVEL=0 ZB_TRACE_MASK=0 ZIGBEE_CLI_DEBUG=1 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\..\components\libraries\cli\cdc_acm;..\..\..\..\..\..\..\components\libraries\cli\rtt;..\..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\components\softdevice\mbr\nrf52840\headers;..\..\..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\..\..\components\zigbee\cli;..\..\..\..\..\..\..\components\zigbee\common;..\..\..\..\..\..\multiprotocol\app_utils;..\..\..;..\..\..\..\..\..\..\external\fnmatch;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features\ack_generator;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch\raal\softdevice;..\..\..\..\..\..\..\external\nano-pb;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\nrf_cc310_bl\include;..\..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\..\external\zboss\addons;..\..\..\..\..\..\..\external\zboss\include;..\..\..\..\..\..\..\external\zboss\include\ha;..\..\..\..\..\..\..\external\zboss\include\osif;..\..\..\..\..\..\..\external\zboss\include\zcl;..\..\..\..\..\..\..\external\zboss\osif;..\..\..\..\..\..\..\external\zboss\zb_error;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEBUG DEBUG_NRF ENABLE_FEM FLOAT_ABI_HARD KEIL MULTIPROTOCOL_802154_CONFIG_PRESENT NRF52840_XXAA NRF_BL_SETTINGS_PAGE_PROTECT=0 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 ZB_TRACE_LEVEL=0 ZB_TRACE_MASK=0 ZIGBEE_CLI_DEBUG=1 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG,-DDEBUG_NRF,-DENABLE_FEM,-DFLOAT_ABI_HARD,-DKEIL,-DMULTIPROTOCOL_802154_CONFIG_PRESENT,-DNRF52840_XXAA,-DNRF_BL_SETTINGS_PAGE_PROTECT=0,-DNRF_DFU_SETTINGS_VERSION=2,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=6,-DS140,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-DZB_TRACE_LEVEL=0,-DZB_TRACE_MASK=0,-DZIGBEE_CLI_DEBUG=1,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002450 size 0x3dbb0
  link misc: --diag_suppress 6330
  group None
    ../../../../../../multiprotocol/app_utils/: multiprotocol_802154_config.c
  group Application
    ../../../../../../dfu/: dfu_public_key.c
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../../../../../../../external/utf_converter/: utf.c
  group Zigbee
    ../../../../../../../external/zboss/lib/keil/: libzboss.lib nrf_radio_driver_softdevice.lib
    ../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_ota.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
    ../../../../../../../external/zboss/addons/zcl/: zb_zcl_common_addons.c zb_zcl_ota_upgrade_addons.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_srv_common.c
  group nRF_Crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend CC310_BL
    ../../../../../../../components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_DFU
    ../../../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../../../../../components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../../external/fnmatch/: fnmatch.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../../components/libraries/cli/cdc_acm/: nrf_cli_cdc_acm.c
    ../../../../../../../components/libraries/cli/rtt/: nrf_cli_rtt.c
    ../../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_2.0.7.lib
  group nRF_SVC
    ../../../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../../../../../components/libraries/svc/: nrf_svc_handler.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Zigbee
    ../../../../../../../components/zigbee/cli/: zigbee_cli.c zigbee_cli_cmd.c zigbee_cli_cmd_attr.c zigbee_cli_cmd_attr_report.c zigbee_cli_cmd_bdb.c zigbee_cli_cmd_generic_cmd.c zigbee_cli_cmd_ping.c zigbee_cli_cmd_radio.c zigbee_cli_cmd_zcl.c zigbee_cli_cmd_zdo.c zigbee_cli_cmd_zscheduler.c zigbee_cli_utils.c
    ../../../../../../../components/zigbee/common/: zigbee_helpers.c zigbee_logger_eprxzcl.c
  group nano-pb
    ../../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nrf_cc310_bl
    ../../../../../../../external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_bl_0.9.12.lib
target flash_s140_nrf52_6.1.1_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s140_nrf52_6.1.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002450 size 0x3dbb0
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
