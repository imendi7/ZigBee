# IAR project zigbee_multi_sensor_freertos_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; FREERTOS; NRF52840_XXAA; ZB_ED_ROLE; ZB_TRACE_LEVEL=0; ZB_TRACE_MASK=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\components\zigbee\common; ..\..\..\..\..\..\..\components\zigbee\pressure_cluster; ..\..\..; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features\ack_generator; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch; ..\..\..\..\..\..\..\external\zboss\addons; ..\..\..\..\..\..\..\external\zboss\include; ..\..\..\..\..\..\..\external\zboss\include\ha; ..\..\..\..\..\..\..\external\zboss\include\osif; ..\..\..\..\..\..\..\external\zboss\include\zcl; ..\..\..\..\..\..\..\external\zboss\osif; ..\..\..\..\..\..\..\external\zboss\zb_error; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_multi_sensor_freertos_pca10056.hex
  ILINK.IlinkOutputFile: zigbee_multi_sensor_freertos_pca10056.out
  ILINK.IlinkIcfFile: zigbee_multi_sensor_freertos_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Third Parties
    ../../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../../external/freertos/portable/IAR/nrf52/: port.c
    ../../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Zigbee
    ../../../../../../../external/zboss/lib/iar/: libzboss.ed.a nrf_radio_driver.a
    ../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_ota.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
    ../../../../../../../external/zboss/addons/zcl/: zb_zcl_common_addons.c zb_zcl_ota_upgrade_addons.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_Zigbee
    ../../../../../../../components/zigbee/pressure_cluster/: zb_zcl_pressure_measurement.c
    ../../../../../../../components/zigbee/common/: zigbee_helpers.c zigbee_logger_eprxzcl.c
