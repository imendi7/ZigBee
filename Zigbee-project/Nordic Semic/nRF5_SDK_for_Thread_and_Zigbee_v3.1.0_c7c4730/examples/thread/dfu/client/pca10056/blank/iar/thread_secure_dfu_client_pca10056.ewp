# IAR project thread_secure_dfu_client_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; MBEDTLS_CONFIG_FILE=<mbedtls-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52840-mbedtls-config.h>; MBR_PRESENT; NRF52840_XXAA; NRF_DFU_NO_TRANSPORT; NRF_DFU_SETTINGS_VERSION=2; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_FTD=1; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; SWI_DISABLE0; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\iot\background_dfu; ..\..\..\..\..\..\..\components\iot\background_dfu\transport; ..\..\..\..\..\..\..\components\iot\background_dfu\transport\coap; ..\..\..\..\..\..\..\components\iot\ble_6lowpan; ..\..\..\..\..\..\..\components\iot\coap; ..\..\..\..\..\..\..\components\iot\common; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\softdevice\mbr\nrf52840\headers; ..\..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\..\external\nano-pb; ..\..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\..\external\nrf_oberon; ..\..\..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\..\..\external\nrf_tls; ..\..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\..\external\openthread\include\openthread\platform\mbedtls; ..\..\..\..\..\..\..\external\openthread\project; ..\..\..\..\..\..\..\external\openthread\project\nrf52840; ..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thread_secure_dfu_client_pca10056.hex
  ILINK.IlinkOutputFile: thread_secure_dfu_client_pca10056.out
  ILINK.IlinkIcfFile: thread_secure_dfu_client_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: libnrf_cc310_0.9.12.a
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group OpenThread
    ../../../../../../../external/openthread/lib/nrf52840/iar/: libopenthread-cli-ftd.a libopenthread-diag.a libopenthread-ftd.a libopenthread-platform-utils.a libmbedcrypto.a libopenthread-nrf52840-sdk.a libnordicsemi-nrf52840-radio-driver.a libopenthread-platform-utils.a
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Crypto backend uECC
    ../../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nano-pb
    ../../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/sha256/: sha256.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c
  group nRF_Crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group Application
    ../../../../../../dfu/: dfu_public_key.c
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_micro-ecc
    ../../../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Crypto backend nRF sw
    ../../../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Oberon_Crypto
    ../../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_2.0.7.a
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_DFU
    ../../../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_IoT
    ../../../../../../../components/iot/background_dfu/: background_dfu_block.c background_dfu_operation.c background_dfu_state.c
    ../../../../../../../components/iot/coap/: coap.c coap_block.c coap_message.c coap_option.c coap_queue.c coap_resource.c coap_transport_ot.c
    ../../../../../../../components/iot/background_dfu/transport/coap/: coap_dfu.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Crypto backend Oberon
    ../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Thread
    ../../../../../../../components/thread/utils/: thread_utils.c
