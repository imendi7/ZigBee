# Keil uVision project thread_cli_ftd_usb_pca10059_mbr.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10059 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<mbedtls-config.h> MBEDTLS_USER_CONFIG_FILE=<nrf52840-mbedtls-config.h> MBR_PRESENT NRF52840_XXAA OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h> OPENTHREAD_FTD=1 SWI_DISABLE0 USBD_POWER_DETECTION=1 __HEAP_SIZE=0 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\softdevice\mbr\nrf52840\headers;..\..\..\..\..\..\..\..\components\thread\utils;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\..\external\openthread\include;..\..\..\..\..\..\..\..\external\openthread\include\openthread\platform\mbedtls;..\..\..\..\..\..\..\..\external\openthread\project;..\..\..\..\..\..\..\..\external\openthread\project\nrf52840;..\..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: BOARD_PCA10059 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBR_PRESENT NRF52840_XXAA OPENTHREAD_FTD=1 SWI_DISABLE0 USBD_POWER_DETECTION=1 __HEAP_SIZE=0 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10059,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DMBR_PRESENT,-DNRF52840_XXAA,-DOPENTHREAD_FTD=1,-DSWI_DISABLE0,-DUSBD_POWER_DETECTION=1,-D__HEAP_SIZE=0,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xfb000
  memory RVCT9: RAM 0x20000008 size 0x3fff8
  link misc: --diag_suppress 6330
  group Application
    ../../../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group OpenThread
    ../../../../../../../../external/openthread/lib/nrf52840/keil/: libopenthread-cli-ftd.lib libopenthread-diag.lib libopenthread-ftd.lib libopenthread-platform-utils.lib libmbedcrypto.lib libopenthread-nrf52840-sdk-usb.lib libnordicsemi-nrf52840-radio-driver.lib libopenthread-platform-utils.lib
  group UTF8/UTF16 converter
    ../../../../../../../../external/utf_converter/: utf.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_systick.c nrfx_usbd.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Thread
    ../../../../../../../../components/thread/utils/: thread_utils.c
  group nrf_cc310
    ../../../../../../../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_0.9.12.lib
target flash_mbr (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: as above
  output: mbr_nrf52_2.4.1_mbr.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xdb000
  memory RVCT9: RAM 0x20000008 size 0x3fff8
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
